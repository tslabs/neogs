-cz80
-Fraw-binary
-Z(CODE)CODE=0000-FFFF
