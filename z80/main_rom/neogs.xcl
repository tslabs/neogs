// xcl-file for assembler-only projects
-Fraw-binary
-cz80
-Z(CODE)CODE=0000-FFFF
-o neogs.rom
-l neogs.map
-xmisn
